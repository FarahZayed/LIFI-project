# IAR project project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C123GH6PM TexasInstruments TM4C123GH6PM
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCIncludePath2: D:\koleya\senior 1\embedded\project\tiva project; D:\koleya\senior 1\embedded\project\tiva project\HAL; D:\koleya\senior 1\embedded\project\tiva project\MCAL; D:\koleya\senior 1\embedded\project\tiva project\LIB; D:\koleya\senior 1\embedded\project\tiva project\HAL\buttons
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    MCAL/: bitwise_operations.h DIO.c DIO.h ports.h
    HAL/Bluetooth/: bluetooth.c bluetooth.h
    HAL/buttons/: buttons.c buttons.h
    HAL/Fume/: fume.c fume.h
    HAL/Laser/: laser.c laser.h
    HAL/magnetic/: magnetic.c magnetic.h
    ./: main.c
    LIB/: std_types.h tm4c123gh6pm.h
    HAL/UltraSonic/: ultrasonic.c ultrasonic.h
